# IAR project Project_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Appl
    Sprints_ARM_MC02/src/Appl/: Main.c
  group common
    Sprints_ARM_MC02/src/Common/: Compiler.h Mcu_Hw.h Platform_Types.h Std_Types.h TM4C123GH6PM.h
  group Config
    Sprints_ARM_MC02/src/Config/: GPIO_Cfg.h IntCtrl_Cfg.h IntCtrl_Lcfg.c
  group Mcal
    Sprints_ARM_MC02/src/Mcal/: GPIO.c IntCtrl.c
  group Mcal/Inc
    Sprints_ARM_MC02/src/Mcal/Inc/: GPIO.h IntCtrl.h IntCtrl_Types.h
